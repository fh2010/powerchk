# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L151xB,USE_HAL_DRIVER
  c include: .\component\drivers\include;.\component\FreeRTOS\Source\include;.\component\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\include;.\board\bsp;.\board\include;.\board\driver\inc;.\board\STM32L1xx_HAL\STM32L1xx_HAL_Driver\Inc;.\board\STM32L1xx_HAL\STM32L1xx_HAL_Driver\Inc\Legacy;.\board\STM32L1xx_HAL\CMSIS\Include;.\board\STM32L1xx_HAL\CMSIS\Device\ST\STM32L1xx\Include;.\device\console
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group application
    ./application/: main.c
  group component/FreeRTOS
    ./component/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./component/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./component/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group device
    ./device/console/: dev_console.c
  group board/driver
    ./board/driver/src/: drv_uart.c drv_device.c drv_object.c
  group board/lib
    ./board/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group board/cmsis
    ./board/bsp/: board.c
    ./board/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/: stm32l1xx_it.c system_stm32l1xx.c stm32l1xx_hal_msp.c
    ./board/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xb.s
